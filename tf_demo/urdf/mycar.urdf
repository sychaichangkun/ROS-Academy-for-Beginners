Commit message: 修改并补充tf_demo

File: tf_demo/urdf/mycar.urdf (robot description, URDF)
Before this commit: robot test_robot, 4 links, 3 joints
Links:
- link rplidar: geometry collision cylinder length=.04 radius=0.035; visual mesh filename=package://tf_demo/urdf/rplidar.dae
